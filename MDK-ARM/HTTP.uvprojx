# Keil uVision project HTTP.uvprojx, settings and files
target HTTP (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F746NGHx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.9.0
  cpu: IRAM(0x20000000-0x2004FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(12000000) FPU3(SFPU) CPUTYPE("Cortex-M7") ELITTLE
  output: HTTP
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F746xx
  c include: ../Inc;    ../Middlewares/Third_Party/LwIP/src/include;    ../Middlewares/Third_Party/LwIP/system;    ../Drivers/STM32F7xx_HAL_Driver/Inc;    ../Drivers/STM32F7xx_HAL_Driver/Inc/Legacy;    ../Middlewares/Third_Party/LwIP/src/include/netif/ppp;    ../Drivers/CMSIS/Device/ST/STM32F7xx/Include;    ../Middlewares/Third_Party/LwIP/src/include/lwip;    ../Middlewares/Third_Party/LwIP/src/include/lwip/apps;    ../Middlewares/Third_Party/LwIP/src/include/lwip/priv;    ../Middlewares/Third_Party/LwIP/src/include/lwip/prot;    ../Middlewares/Third_Party/LwIP/src/include/netif;    ../Middlewares/Third_Party/LwIP/src/include/posix;    ../Middlewares/Third_Party/LwIP/src/include/posix/sys;    ../Middlewares/Third_Party/LwIP/system/arch;    ../Drivers/CMSIS/Include;    ..\fs;   ../Middlewares/Third_Party/LwIP/src/apps/httpd
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x50000
  group Application/MDK-ARM
    ./: startup_stm32f746xx.s
  group Middlewares/LwIP
    ../Middlewares/Third_Party/LwIP/src/core/: inet_chksum.c ip.c tcp.c timeouts.c memp.c init.c raw.c mem.c dns.c netif.c def.c stats.c tcp_in.c sys.c pbuf.c tcp_out.c udp.c
    ../Middlewares/Third_Party/LwIP/src/netif/ppp/: vj.c chap-new.c pppcrypt.c lcp.c mppe.c multilink.c chap_ms.c demand.c ccp.c eui64.c ppp.c ecp.c pppoe.c ipv6cp.c pppos.c chap-md5.c pppapi.c upap.c fsm.c auth.c pppol2tp.c eap.c magic.c ipcp.c utils.c
    ../Middlewares/Third_Party/LwIP/src/core/ipv6/: ip6.c ethip6.c mld6.c ip6_frag.c dhcp6.c nd6.c ip6_addr.c icmp6.c inet6.c
    ../Middlewares/Third_Party/LwIP/src/core/ipv4/: ip4_addr.c igmp.c ip4.c autoip.c etharp.c dhcp.c icmp.c ip4_frag.c
    ../Middlewares/Third_Party/LwIP/src/api/: err.c netdb.c netifapi.c api_msg.c netbuf.c tcpip.c api_lib.c sockets.c
    ../Middlewares/Third_Party/LwIP/src/netif/: slipif.c ethernet.c lowpan6.c
    ../Middlewares/Third_Party/LwIP/src/apps/mqtt/: mqtt.c
    ../Middlewares/Third_Party/LwIP/src/apps/httpd/: fs.c httpd.c
  group Drivers/STM32F7xx_HAL_Driver
    ../Drivers/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal_i2c_ex.c stm32f7xx_hal_i2c.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_pwr.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal.c stm32f7xx_hal_gpio.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal_flash.c stm32f7xx_hal_eth.c stm32f7xx_hal_cortex.c stm32f7xx_hal_tim.c stm32f7xx_hal_flash_ex.c stm32f7xx_hal_dma.c stm32f7xx_hal_tim_ex.c stm32f7xx_hal_rcc.c
  group Application/User
    ../Src/: stm32f7xx_hal_msp.c ethernetif.c stm32f7xx_it.c main.c lwip.c
    ../Inc/: test.h
    ../fs/: http_server.c
  group Drivers/CMSIS
    ..//Src/: system_stm32f7xx.c
software components: CMSIS:CORE 4.3.0
